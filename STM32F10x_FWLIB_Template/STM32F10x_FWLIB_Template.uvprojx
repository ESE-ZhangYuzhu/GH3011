# Keil uVision project STM32F10x_FWLIB_Template.uvprojx, settings and files
target STM32F103RCT6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x_FWLIB_Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\App;.\CMSIS;.\MDK_ARM_StartUp;.\STM32F10x_Std_Driver\inc;.\STM32F10x_Std_Driver\src;.\Device;.\ISR;.\User;.\Device\GH3011
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group MDK_ARM_StartUp
    ./MDK_ARM_StartUp/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group STM32F10x_Std_Driver
    ./STM32F10x_Std_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_exti.c
  group ISR
    ./ISR/: stm32f10x_it.c
  group Device
    ./Device/GH3011/: GH3011.c hbd_ctrl_KEIL5_M3.lib ConfigArr.c
  group App
    ./App/: SysTick.c UART.c I2C.c SPI.c
  group User
    ./User/: main.c SystemInit.c
